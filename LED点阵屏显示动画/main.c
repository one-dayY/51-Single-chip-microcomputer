#include <REGX52.H>
#include "Delay.h"
#include "MatrixLED.h"

unsigned char code Animation[] = 
{
	0xFF,0x08,0x08,0x08,0xFF,0x1C,0x2A,0x2A,0x2A,0x18,0xFF,0x01,0x02,0xFF,0x01,0x02,
	0x7E,0x81,0x81,0x7E,0x00,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};

void main()
{
	unsigned char i,Offset,Count = 0;
	
	MatrixLED_Init();
	while(1)
	{
		for(i = 0; i < 8; i++)
		{
			MatrixLED_ShowColumn(i,Animation[i + Offset]);
		}
		Count++;
		if(Count > 10)
		{
			Count = 0;
			Offset++;
			if(Offset > 24)
			{
				Offset = 0;
			}
		}
	}
}